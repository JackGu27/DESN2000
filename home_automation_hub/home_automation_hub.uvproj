# Keil uVision project home_automation_hub.uvproj, settings and files
target QVGA Base Board (ARM-ADS)
  device: LPC2478 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x4000FFFF) IRAM2(0x7FE00000-0x7FE03FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: home_automation_hub
  c flags: Optim=1 wLevel=2
  asm misc: --diag_suppress 1608,6314
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x10000
  memory RVCT10: RAM 0x7fe00000 size 0x4000
  link misc: --first=LPC2400.o(RESET) --bestdebug --arm_only
  group Startup
    ./src/: LPC2400.s
  group Source Code
    ./src/: main.c light.c led.c button.c clock.c speaker.c songs.c automation.c decision.s
